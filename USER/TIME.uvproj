# Keil uVision project TIME.uvproj, settings and files
target TIME (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TIME
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\EXTI;..\HARDWARE\GPS;..\HARDWARE\SPI;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/GPS/: gps.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
